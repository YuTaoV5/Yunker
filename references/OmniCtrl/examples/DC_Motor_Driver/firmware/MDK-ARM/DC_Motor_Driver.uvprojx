# Keil uVision project DC_Motor_Driver.uvprojx, settings and files
target DC_Motor_Driver (6230000::V6.23::ARMCLANG)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DC_Motor_Driver +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Inc;../HDL/Inc;../UI/Inc;../APP/Inc;..\..\..\..\OmniCtrl\firmware;..\..\..\..\OmniCtrl\firmware\bases\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c rtc.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/BSP
    ../Drivers/BSP/Src/: bsp_common.c bsp_gpio.c bsp_spi.c bsp_tim.c bsp_uart.c bsp_rtc.c bsp_flash.c
  group HDL
    ../HDL/Src/: OLED.c log.c key.c A4950.c Encoder.c Motor.c SysTimer.c comm.c Flash.c
  group OmniCtrl
    ../../../../OmniCtrl/firmware/: control_core.c
    ../../../../OmniCtrl/firmware/bases/Src/: algorithms_math.c control_comm.c control_config.c control_log.c control_types.c
    ../../../../OmniCtrl/firmware/methods/Src/: ctrl_factory.c ctrl_hash.c ctrl_pool.c ctrl_registry.c ctrl_wiring.c
    ../../../../OmniCtrl/firmware/modules/Src/: branch_judge.c curve_accel.c gain_controller.c incremental_pid.c limit_controller.c mean_filter.c offset_controller.c positional_pid.c ramp_injector.c
  group UI
    ../UI/Src/: ui_menu.c
  group APP
    ../APP/Src/: app_main.c app_oled.c app_key.c app_comm.c app_ctrl.c app_system.c app_boot.c
software components: CMSIS:CORE 5.6.0
